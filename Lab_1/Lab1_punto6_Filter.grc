options:
  parameters:
    author: Josman_Rico_Julian_Romero_B1C_G5
    generate_options: qt_gui
    id: Lab1_punto6
    output_language: python
    title: Lab1_punto6_Filter
  states: {}

blocks:
- name: BW
  id: variable_qtgui_range
  parameters:
    label: Ancho de banda
    start: '10'
    step: '10'
    stop: '50000'
    value: '1500'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: f_corte
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de corte
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia central
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: fc + BW/2
    interp: '1'
    low_cutoff_freq: fc - BW/2
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\julia\OneDrive\Documentos\UIS\Documentos Semestre 7\Comunicaciones 1\Laboratorio\Lab_1\TheBeatles _Don'tLetMeDown.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: f_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
    wintype: window.WIN_KAISER
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '48000'
    type: fff
  states: {}

connections:
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [high_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
